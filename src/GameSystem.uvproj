# Keil uVision project GameSystem.uvproj, settings and files
target LPC1787 (ARM-ADS)
  device: LPC1787 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: GameSystem +hex
  c flags: wLevel=1
  c include: .\app;.\app\appmgr;.\app\mainmenu;.\app\options;.\app\pong;.\app\splash;.\app\statemgr;.\app\syscheck;.\core;.\core\core_cm;.\core\lpc177x_8x;.\core\main;.\core\systasks;.\drv;.\drv\adc;.\drv\clk;.\drv\dac;.\drv\exti;.\drv\gpdma;.\drv\gpio;.\drv\i2c;.\drv\i2s;.\drv\lcd;.\drv\mci;.\drv\nvic;.\drv\pinsel;.\drv\pwm;.\drv\systick;.\drv\timer;.\drv\uart;.\drv\wwdt;.\os;.\os\croutine;.\os\FreeRTOS;.\os\list;.\os\MemMang;.\os\port;.\os\queue;.\os\task;.\os\timer;.\drv\emc;.\svc;.\svc\iobtn;.\svc\iojs;.\svc\iolcd;.\svc\iomgr;.\svc\iosdram;.\svc\iospkr;.\svc\swim
  asm include: .\drv;.\drv\adc;.\drv\clk;.\drv\dac;.\drv\gpio;.\drv\i2c;.\drv\i2s;.\drv\lcd;.\drv\pinsel;.\drv\pwm;.\drv\systick;.\drv\timer;.\drv\uart;.\os;.\os\croutine;.\os\FreeRTOS;.\os\list;.\os\MemMang;.\os\port;.\os\queue;.\os\task;.\os\timer
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0xa0000000 size 0x10000000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group app/appmgr
    ./app/appmgr/: appmgr.c appmgr.h
  group app/mainmenu
    ./app/mainmenu/: mainmenu.c mainmenu.h mainmenu_cfg.h
  group app/options
    ./app/options/: options.c options.h options_cfg.h
  group app/pong
    ./app/pong/: pong.c pong.h pong_cfg.h
  group app/splash
    ./app/splash/: splash.c splash.h splash_cfg.h
  group app/statemgr
    ./app/statemgr/: statemgr.c statemgr.h statemgr_cfg.h
  group app/syscheck
    ./app/syscheck/: syscheck.c syscheck.h syscheck_cfg.h
  group core
    ./core/: pinmacro.h
  group core/core_cm
    ./core/core_cm/: core_cm3.c core_cm3.h core_cmFunc.h core_cmInstr.h
  group core/lpc177x_8x
    ./core/lpc177x_8x/: LPC177x_8x.h system_LPC177x_8x.c system_LPC177x_8x.h
  group core/main
    ./core/main/: main.c startup_LPC177x_8x.s
  group core/systasks
    ./core/systasks/: systasks.c systasks.h
  group drv
    ./drv/: lpc_types.h
  group drv/adc
    ./drv/adc/: lpc177x_8x_adc.c lpc177x_8x_adc.h
  group drv/clk
    ./drv/clk/: lpc177x_8x_clkpwr.c lpc177x_8x_clkpwr.h lpc177x_8x_rtc.c lpc177x_8x_rtc.h
  group drv/gpdma
    ./drv/gpdma/: lpc177x_8x_gpdma.c lpc177x_8x_gpdma.h
  group drv/gpio
    ./drv/gpio/: lpc177x_8x_gpio.c lpc177x_8x_gpio.h
  group drv/emc
    ./drv/emc/: lpc177x_8x_emc.c lpc177x_8x_emc.h
  group drv/lcd
    ./drv/lcd/: lpc18xx_lcd.c lpc18xx_lcd.h lpc18xx_libcfg_default.h
  group drv/pinsel
    ./drv/pinsel/: lpc177x_8x_pinsel.c lpc177x_8x_pinsel.h
  group drv/pwm
    ./drv/pwm/: lpc177x_8x_pwm.c lpc177x_8x_pwm.h
  group drv/systick
    ./drv/systick/: lpc177x_8x_systick.c lpc177x_8x_systick.h
  group drv/timer
    ./drv/timer/: lpc177x_8x_timer.c lpc177x_8x_timer.h
  group os
    ./os/: mpu_wrappers.h portable.h projdefs.h semphr.h StackMacros.h
  group os/croutine
    ./os/croutine/: croutine.c croutine.h
  group os/FreeRTOS
    ./os/FreeRTOS/: FreeRTOS.h FreeRTOSConfig.h
  group os/list
    ./os/list/: list.c list.h
  group os/MemMang
    ./os/MemMang/: heap_1.c
  group os/port
    ./os/port/: port.c portmacro.h
  group os/queue
    ./os/queue/: queue.c queue.h
  group os/task
    ./os/task/: task.h tasks.c
  group os/timer
    ./os/timer/: timers.c timers.h
  group svc/iobtn
    ./svc/iobtn/: iobtn.c iobtn.h iobtn_cfg.h
  group svc/iojs
    ./svc/iojs/: iojs.c iojs.h iojs_cfg.h
  group svc/iolcd
    ./svc/iolcd/: iolcd.c iolcd.h iolcd_cfg.h
  group svc/iomgr
    ./svc/iomgr/: iomgr.c iomgr.h iomgr_cfg.h
  group svc/iosdram
    ./svc/iosdram/: iosdram.c iosdram.h iosdram_cfg.h
  group svc/iospkr
    ./svc/iospkr/: iospkr.c iospkr.h iospkr_cfg.h
  group svc/swim
    ./svc/swim/: lpc_colors.c lpc_colors.h lpc_fonts.c lpc_fonts.h lpc_helvr10.c lpc_helvr10.h lpc_rom8x8.c lpc_rom8x8.h lpc_rom8x16.c lpc_rom8x16.h lpc_swim.c lpc_swim.h lpc_swim_font.c lpc_swim_font.h lpc_swim_image.c lpc_swim_image.h lpc_winfreesystem14x16.c lpc_winfreesystem14x16.h lpc_x5x7.c lpc_x5x7.h lpc_x6x13.c lpc_x6x13.h
